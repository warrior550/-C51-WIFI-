# Keil uVision project template.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: template +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: C:\Keil_v5\C51\INC;C:\Keil_v5\C51\INC\Atmel;..\project;..\source
  group SourceFiles
    ../source/: main.c motor.c timer_ISR.c Delay.c LCD1602.c ultrasonic.c app.c servo.c
    ./: uart_ISR.c
  group InlucdeFiles
    ../source/: config.h main.h motor.h timer_ISR.h Delay.h LCD1602.h app.h ultrasonic.h Servo.h
    ./: uart_ISR.h
